EXTRA_OECONF:append = " --with-zlib=${STAGING_DIR_HOST}${prefix} "
