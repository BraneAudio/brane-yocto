PACKAGECONFIG:class-target = "gdbm"

