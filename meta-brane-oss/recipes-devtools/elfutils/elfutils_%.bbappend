# Make sure that bzip is included in elfutils since that is the way it has
# always been for us.

PACKAGECONFIG:class-target ?= "bzip2"


