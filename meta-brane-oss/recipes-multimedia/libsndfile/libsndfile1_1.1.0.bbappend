EXTRA_OECONF = " \
   --disable-external-libs \
"

